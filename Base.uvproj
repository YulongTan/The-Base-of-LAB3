# Keil uVision project Base.uvproj, settings and files
target Target 1 (MCS-51)
  device: C8051F310 Silicon Labs
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF) IROM(0-0x3FFF) CLOCK(25000000)
  output: Base
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\Base
  asm include: ..\Base
  group Source Group 1
    ./: main.a51
